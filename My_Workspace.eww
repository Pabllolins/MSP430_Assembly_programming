<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Codes\0_FlashLED\0_FlashLED.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Codes\1_Projeto_2_MSP430G2231\1_Projeto_2_MSP430G2231.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Codes\2_Video_37_e_38_PORTAS\2_Video_37_e_38_PORTAS.ewp</path>
    </project>
    <batchBuild />
</workspace>
